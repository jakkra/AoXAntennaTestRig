## sdkconfig.defaults
```kconfig
CONFIG_DEFAULT_AP_SSID="AoX-tester"
CONFIG_DEFAULT_AP_PASSWORD=""

CONFIG_HTTPD_WS_SUPPORT=y
CONFIG_HTTPD_MAX_REQ_HDR_LEN=2048
```
